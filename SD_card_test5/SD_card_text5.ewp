# IAR project SD_card_text5.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SD_card_text5.hex
  ILINK.IlinkOutputFile: SD_card_text5.out
  ILINK.IlinkIcfFile: C:\Users\Aaron\Documents\Watch-dev\Code\SD_card_test5\LPC2103.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: gps.c gps.h interrupts.c interrupts.h main.c main.h mmc.c mmc.h spi.c spi.h uart.c uart.h
